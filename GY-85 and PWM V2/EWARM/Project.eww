<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\GY-85 and PWM.ewp</path>
  </project>
  <batchBuild />
</workspace>
